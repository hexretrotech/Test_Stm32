# IAR project Test01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\Test_Stm32\STM32F10x_StdPeriph_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; D:\Test_Stm32\STM32F10x_StdPeriph_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc\; D:\Test_Stm32\STM32F10x_StdPeriph_Lib\Project\STM32F10x_StdPeriph_Template\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  AARM.AUserIncludes: D:\Test_Stm32\STM32F10x_StdPeriph_Lib\Libraries\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; D:\Test_Stm32\STM32F10x_StdPeriph_Lib\Libraries\Libraries\STM32F10x_StdPeriph_Driver\inc\; D:\Test_Stm32\STM32F10x_StdPeriph_Lib\Project\STM32F10x_StdPeriph_Template\
  OBJCOPY.OOCOutputFile: Test01.hex
  ILINK.IlinkOutputFile: Test01.out
  ILINK.IlinkIcfFile: D:\Test_Stm32\linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries/CMSIS/c
    STM32F10x_StdPeriph_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries/CMSIS/h
    STM32F10x_StdPeriph_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group Libraries/StandartPeripheralLibrary/c
    STM32F10x_StdPeriph_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group Libraries/StandartPeripheralLibrary/h
    STM32F10x_StdPeriph_Lib/Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_gpio.h stm32f10x_rcc.h
  group Sources
    ./: main.c
